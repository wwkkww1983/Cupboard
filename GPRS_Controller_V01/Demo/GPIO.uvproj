# Keil uVision project GPIO.uvproj, settings and files
target Demo (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Code;.\Code\MyPt;.\Code\MyPt\pt-1.4
  group User_Source
    ./Code/: main.c detection_control.c uart0.c
  group User_Head
    ./Code/: N76E003.h m_include.h main.h at24c02.h detection_control.h key.h uart0.h
  group Pt
    ./Code/MyPt/: systick.c thread.c typedef.h sem.c
  group Startup
    ./Code/: STARTUP.A51
